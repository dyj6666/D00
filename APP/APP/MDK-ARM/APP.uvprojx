# Keil uVision project APP.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: APP +hex
  AfterMake: cmd /c post_build_app.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE,__STDC_LIMIT_MACROS
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../Ports;../Middlewares/Third_Party/lvgl;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Config;../BSP;../SystemServices;../Application;../Drivers;../LWIP/App;../LWIP/Target;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/compat/posix;../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/LwIP/system/arch
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: APP\APP.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: i2c.c main.c gpio.c freertos.c dma.c fsmc.c iwdg.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Config
    ../Config/: app_config.h pinout.h app_footer.c
  group SystemServices
    ../SystemServices/: logger.c shell.c cmd_shell.c ext_store.c cmd_shell.h cmd_can.c cmd_can.h net_config.c net_config.h usr_store.c usr_store.h event_bus.c module.c sysmon.c var_manager.c data_link.c crc16.c protocol.c var_list.c watchdog.c err_mgr.c la_sample.c signal_gen.c la_buffer.c la_trigger.c touch_svc.c cam_link.c imu_fusion.c imu_svc.c
    ../Application/: cmd_catalog.h
  group Application
    ../Application/: cmd_catalog.c key_app.c led_app.c ota_agent.c ota_can_svc.c data_agent.c buzzer_app.c eth_app.c tcp_svc.c icmp_svc.c dns_svc.c sntp_svc.c mqtt_svc.c http_svc.c ota_mgr.c ota_tcp_svc.c ota_http_svc.c gui_app.c gui_theme.c gui_pages.c
    ../Ports/: lv_port.c lv_port_disp.c lv_port_indev.c
    ../Core/Src/: sys_assert.c
  group Middlewares/LVGL
    ../Middlewares/Third_Party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/Third_Party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/Third_Party/lvgl/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/Third_Party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/Third_Party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/Third_Party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group BSP
    ../BSP/: bsp_system.c bsp_flash.c bsp_uart.c bsp_can.c bsp_can.h bsp_power.c bsp_power.h bsp_i2c.c bsp_i2c.h bsp_eeprom.c bsp_w25q128.c bsp_eeprom.h bsp_watchdog.c bsp_rtc.c bsp_gpio.c bsp_lcd.c bsp_touch.c bsp_buzzer.c bsp_mpu6050.c
    ../BSP/LCD/: lcd.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c eth_custom_phy_interface.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
software components: CMSIS:CORE 4.3.0
